options:
  parameters:
    author: Edvard
    generate_options: qt_gui
    id: sbandtx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '19531'
  states: {}
- name: cons
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / baudrate)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: disco_ZMQ_source_0
  id: disco_ZMQ_source
  parameters:
    connection_str: tcp://127.0.0.1:6666
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_2, '0']
- [digital_diff_encoder_bb_0, '0', fec_encode_ccsds_27_bb_0, '0']
- [disco_ZMQ_source_0, PDU_out, blocks_message_debug_0, print]
- [disco_ZMQ_source_0, PDU_out, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_encode_ccsds_27_bb_0, '0', digital_constellation_modulator_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_diff_encoder_bb_0, '0']

metadata:
  file_format: 1
