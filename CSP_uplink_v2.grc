options:
  parameters:
    generate_options: qt_gui
    id: CSP_uplink_v2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: length_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("packet_len")
    offset: '0'
    src: pmt.intern("src")
    value: ' pmt.from_long(10)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: '5000'
    dac: '10000'
    dc_calibration: LPF_TUNING
    device_id: '0'
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: 437e6
    gain0: '30'
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thomas/Desktop/GFSK_test.bin
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      NOTE: length depends on CSP message length
      (set manually for now)
    len_tag_key: '"packet_len"'
    packet_len: '42'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '42'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      This is the actual CSP data
      (header + payload)
    repeat: 'False'
    tags: '[length_tag]'
    type: byte
    vector: (0x80, 0x81, 0x02, 0xc8, 0x15, 0x41, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xa9'
    reset_tag_key: packet_len
    seed: '0xff'
  states: {}
- name: digital_additive_scrambler_bb_1
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    comment: scramble the signal
    count: '0'
    len: '7'
    mask: '0xa9'
    reset_tag_key: '"packet_len"'
    seed: '0xff'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.7'
    do_unpack: 'False'
    samples_per_symbol: '250'
    sensitivity: '0.1'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '1'
    do_unpack: 'False'
    samples_per_symbol: '250'
  states: {}
- name: digital_gmskmod_bc_0
  id: digital_gmskmod_bc
  parameters:
    L: '500'
    bt: '0.3'
    samples_per_symbol: '250'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    This block takes packed bits and looks for 5 consequitive 1 bits,\n    which upon discovy a 0 bit it inserted right after the 5 consequitive bits. \n\n    PDU_in: packed bits (bytes)\n    PDU_out: unpacked bits\n    \"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Bit stuffer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None,\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('PDU_in'))\n        self.message_port_register_out(pmt.intern('PDU_out'))\n        self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        #Get bytestream from PDU\n        bytestream = np.array(pmt.to_python(pmt.cdr(msg))) \n\n        #Convert from bytestream to bitstream\n        bitstream = self.bytes_to_bits(bytestream)\n\n        #Stuff the bitstream\n        stuffed_bitstream = self.bit_stuffing(bitstream)\n        \n        #Convert the stuffed bitstream to PDU\n        outgoing_msg = pmt.init_u8vector(len(stuffed_bitstream),(stuffed_bitstream))\n        pdu = pmt.cons(pmt.make_dict(), outgoing_msg)\n\n        self.message_port_pub(pmt.intern('PDU_out'), pdu)\n\n    def bytes_to_bits(self, byte_array):\n        \n        #Create empty list to hold the binary values\n        binary_list = []\n\n        #Loop over the byte array to extract the bits from each byte\n        for byte in byte_array:\n            #remove the 0b formatting by using the slice function\n            binary_str = bin(byte)[2:] \n\n            #insert zero padding in order to verify leading zeros are present\n            binary_str = binary_str.zfill(8)\n\n            #Insert bits into the binary list one at a time\n            binary_list.extend([int(bit) for bit in binary_str])\n        \n        #Convert list to numpy array\n        binary_array = np.array(binary_list)\n\n        return binary_array\n    \n    def bit_stuffing(self, non_stuffed_array, max_consecutive_ones=5, stuff_bit=0):\n        #create stuffed array to hold the new bitstream\n        stuffed_array = []\n\n        consecutive_ones_counter = 0\n\n        #loop over the non stuffed array\n        for bit in non_stuffed_array:\n            if bit == 1:\n                consecutive_ones_counter += 1\n                if consecutive_ones_counter == max_consecutive_ones:\n                    stuffed_array.extend([bit])\n                    stuffed_array.extend([int(stuff_bit)])\n                    consecutive_ones_counter = 0\n                else:\n                    stuffed_array.extend([bit])\n            else:\n                stuffed_array.extend([bit])\n                consecutive_ones_counter = 0\n\n        return np.array(stuffed_array)\n\n\n"
    comment: Bit stuffing
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Remove stuffed bits from a message i.e, the bits followed by 
          five consequitive ones. 
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bit de-stuffer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(msg)) 
              

              """Remove one bit preceded by five consequitive ones"""
              compare_array = np.array([1,1,1,1,1])


              for i in range(len(bitstream)-5):
                  if np.array_equal(bitstream[i:i+5],compare_array):
                      #Mark stuffed bits such that they can be removed later
                      #If they are removed now, the for loop will delete all
                      #consequtive bits if 1111101 is received
                      bitstream[i+5] = 2


              bitstream_destuffed = np.delete(bitstream, np.where(bitstream == 2))

              #Convert destuffed frame to PMT
              outgoing_msg = pmt.init_u8vector(len(bitstream_destuffed),(bitstream_destuffed))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('pdu_out'), pdu)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Gets a message with the front HDLC flag removed by the
          'sync and create PDU block' and this block then removes
          the last HDLC flag and sends the prior bitstream
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="HDLC Deframer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(pmt.cdr(msg))) 


              hdlc_flag = np.array([0,1,1,1,1,1,1,0])
              hdlc_index = 0
              
              #Find HDLC in bitstream
              for i in range(len(bitstream)-len(hdlc_flag)):
                  bitstream_snippet = bitstream[i:i+len(hdlc_flag)]
                  if (np.array_equal(bitstream_snippet,hdlc_flag)):
                      hdlc_index = i
                      break
              
              #localize HDLC frame
              hdlc_frame = bitstream[0:hdlc_index]


              #Convert HDLC frame to PMT
              outgoing_msg = pmt.to_pmt(hdlc_frame)

              self.message_port_pub(pmt.intern('msg_out'), outgoing_msg)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    This block takes packed bits and looks for 5 consequitive 1 bits,\n    which upon discovy a 0 bit it inserted right after the 5 consequitive bits. \n\n    PDU_in: unpacked RS-FEC and scrambled bits\n    PDU_out: unpacked bits ready to be transmitted\n    \"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='DISCO HDLC Framer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None,\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('PDU_in'))\n        self.message_port_register_out(pmt.intern('PDU_out'))\n        self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        #Get bytestream from PDU\n        bitstream = np.array(pmt.to_python(pmt.cdr(msg))) \n\n        #Define various sequences and flags\n        preamble = np.array([1,0,1,0,1,0,1,0]) #34 times in the beginning\n        HDLC_flag = np.array([0,1,1,1,1,1,1,0]) #2 times, once before and after msg\n        post_HDLC_preamble = preamble\n        postamble1 = np.array([0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1])\n        postamble2 = np.array([1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,1,1])\n\n        total_preamble = np.array([])\n\n        for i in range(1000): #changed from 34\n            total_preamble = np.append(total_preamble,preamble)\n\n        bits_to_be_transmitted = np.concatenate((total_preamble[:-1],HDLC_flag,post_HDLC_preamble,bitstream,HDLC_flag,postamble1,postamble2))\n        \n        #Convert the stuffed bitstream to PDU\n        outgoing_msg = pmt.init_u8vector(len(bits_to_be_transmitted),(bits_to_be_transmitted.astype(np.uint8)))\n        pdu = pmt.cons(pmt.make_dict(), outgoing_msg)\n\n        self.message_port_pub(pmt.intern('PDU_out'), pdu)\n\n\n\n\n"
    comment: |-
      HDLC Framing 
      (and various other bits)
      bits are fully framed now.
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: |-
      Convert back to byte stream
      in order to use the additive scrambler
      block
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Convert byte stream into a PDU
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Back to PDU
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '600'
    srate: '1000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.001'
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'False'
    comment: Reed-Solomon Encoding of the packet
    interleave: '1'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '400'
    sync: '"0101010101010101010101010111111010101010"'
    threshold: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RS_encoded
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Rs_encoded_scrambled
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: transmitted_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RS_encoded
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Rs_encoded_scrambled
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: |-
      This simulates perfectly received baseband
      physical layer bits
    stream_id: transmitted_bits
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_tag_gate_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_tag_gate_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_additive_scrambler_bb_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_vector_source_x_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_tag_gate_0, '0']
- [digital_additive_scrambler_bb_1, '0', blocks_tag_gate_1, '0']
- [digital_gfsk_mod_0, '0', bladeRF_sink_0, '0']
- [digital_gfsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', bladeRF_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gmskmod_bc_0, '0', bladeRF_sink_0, '0']
- [digital_gmskmod_bc_0, '0', blocks_file_sink_0, '0']
- [digital_gmskmod_bc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmskmod_bc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, PDU_out, epy_block_2, PDU_in]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_1, msg_out, epy_block_0_0, msg_in]
- [epy_block_2, PDU_out, blocks_message_debug_0_0, print]
- [epy_block_2, PDU_out, pdu_pdu_to_tagged_stream_1, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_additive_scrambler_bb_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_gfsk_mod_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_gmsk_mod_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_gmskmod_bc_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', virtual_sink_2, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_encode_rs_ccsds_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_decode_rs_ccsds_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_1, pdus, virtual_sink_1, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_1, print]
- [satellites_encode_rs_ccsds_0, out, virtual_sink_0, '0']
- [satellites_sync_to_pdu_0, out, epy_block_1, msg_in]
- [virtual_source_0, '0', pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_1, '0', epy_block_0, PDU_in]
- [virtual_source_2, '0', satellites_sync_to_pdu_0, '0']

metadata:
  file_format: 1
